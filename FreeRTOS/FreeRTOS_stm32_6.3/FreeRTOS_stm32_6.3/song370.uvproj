# Keil uVision project song370.uvproj, settings and files
target song370 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: song370 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Libraries;.\Libraries\inc;.\FreeRTOS\include;.\FreeRTOS\portable;.\User;.\FreeRTOS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Libraries/: core_cm3.c
    ./Startup/: startup_stm32f10x_hd.s
  group FreeRTOS
    ./FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/: heap_2.c port.c
  group Libraries
    ./Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c
    ./Libraries/: system_stm32f10x.c
  group user
    ./User/: main.c My_InitTask.c
